COMPATIBLE_MACHINE:myboard = "myboard"
