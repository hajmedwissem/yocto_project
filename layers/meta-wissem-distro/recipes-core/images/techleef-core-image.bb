LICENSE = "MIT"

inherit core-image

